# Keil uVision project points.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: points +hex
  c flags: Optimize=1 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 iic.c main.c
