# Keil uVision project p5_1.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: p5_1 +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c onewire.c
