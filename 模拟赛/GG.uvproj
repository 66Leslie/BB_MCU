# Keil uVision project GG.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: GG +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group USER
    ./: main.c base.c Delay.c key.c seg.c iic.c ds1302.c base.h Delay.h key.h seg.h iic.h tedious.txt ds1302.h
